RDEPENDS_${PN} += " \
    packagegroup-gnome-xserver-base \
    network-manager-applet \
    xfce4-default-config \
"
