PACKAGECONFIG += "datetime-setter sound-setter notify"
