PACKAGECONFIG_DISTRO = "examples accessibility"
