PACKAGECONFIG_DISTRO = "examples accessibility icu"
