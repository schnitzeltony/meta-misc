PACKAGECONFIG = "archive gcr gtk libmtp libgphoto2 samba systemd"
