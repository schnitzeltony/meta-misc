PACKAGECONFIG = "use-egl disable-api-keys-info-bar ignore-lost-context impl-side-painting proprietary-codecs"
